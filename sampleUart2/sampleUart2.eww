<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\..\kcciProject\kcciDevices\kcciDevices.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\sampleUart2.ewp</path>
    </project>
    <batchBuild />
</workspace>
