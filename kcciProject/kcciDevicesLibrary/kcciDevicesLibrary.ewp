# IAR project kcciDevicesLibrary.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F405RG ST STM32F405RG
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_STDPERIPH_DRIVER; STM32F40_41xxx
  ICCARM.CCIncludePath2: C:\Program Files\IAR Systems\Libraries\STM32F4xx_StdPeriph_Driver\inc; C:\Program Files\IAR Systems\Libraries\CMSIS\Device\ST\STM32F4xx\Include; inc; stm32Src
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: kcciDevicesLibrary.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: stm32Src\stm32f405xG.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group cmsis
    ../../../../../../Program Files/IAR Systems/Libraries/CMSIS/Device/ST/STM32F4xx/Source/Templates/iar/: startup_stm32f40_41xxx.s
  group inc
    inc/: adc1.h key.h lcd.h led.h tim10_motor.h tim4_counter.h tim7_fnd.h uart2.h uart4.h wifi.h
  group src
    src/: adc1.c key.c lcd.c tim10_motor.c tim4_counter.c tim7_fnd.c uart2.c uart4.c wifi.c
  group stm32Lib
    ../../../../../../Program Files/IAR Systems/Libraries/STM32F4xx_StdPeriph_Driver/src/: misc.c stm32f4xx_adc.c stm32f4xx_exti.c stm32f4xx_gpio.c stm32f4xx_rcc.c stm32f4xx_syscfg.c stm32f4xx_tim.c stm32f4xx_usart.c
  group stm32Src
    stm32Src/: stm32f4xx_it.c system_stm32f4xx.c
