<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\kcciDevices\kcciDevices.ewp</path>
    </project>
	<project>
        <path>$WS_DIR$\kcciDevicesLibrary\kcciDevicesLibrary.ewp</path>
    </project>
		<project>
        <path>$WS_DIR$\kcciDevicesLib\kcciDevicesLib.ewp</path>
    </project>
    <batchBuild />
</workspace>
